require u-boot-common-2019.07.inc
require u-boot-tools.inc
