require u-boot-common-2019.07.inc
require u-boot.inc

DEPENDS += "bc-native dtc-native"

require u-boot_2019.07_ni.inc
