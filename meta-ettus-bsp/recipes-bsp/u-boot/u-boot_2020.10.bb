require u-boot-common-2020.10.inc
require u-boot.inc

DEPENDS += "bc-native dtc-native"

require u-boot_2020.10_ni.inc
