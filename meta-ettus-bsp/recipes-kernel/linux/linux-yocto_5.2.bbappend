require linux-yocto_5.2_ni.inc
