KBRANCH = "linux-5.10.y"
SRCREV:ni-titanium = "e97bd1e03e6ef58ec47ee7f085f8c14ed6329cf7"
SRCREV_meta ?= "b890cbbdcbc8498d1c84ec782bb5de8a51eb7d6d"
LINUX_VERSION = "5.10.37"
# KBUILD_DEFCONFIG = "x410_defconfig"

require linux-x4xx.inc
require kernel-include-nirio-header.inc
