PACKAGECONFIG:append:ni-e31x = " networkd resolved"
