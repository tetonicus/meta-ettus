PACKAGECONFIG:ni-e31x = "mpmd python"
