EXTRA_OECMAKE:append:ni-sulfur = " -DENABLE_OCTOCLOCK=OFF"

PACKAGECONFIG:ni-sulfur = "mpmd python"
