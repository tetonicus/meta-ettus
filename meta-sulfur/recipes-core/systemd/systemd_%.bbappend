PACKAGECONFIG:append:ni-sulfur = " networkd resolved"
