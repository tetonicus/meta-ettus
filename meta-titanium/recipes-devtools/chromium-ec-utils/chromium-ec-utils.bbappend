SRC_URI:ni-titanium = " \
    git://github.com/EttusResearch/usrp-firmware.git;branch=titanium;protocol=https \
    file://0001-Makefile.toolchain-ignore-stringop-overread-warning.patch \
    "

SRCREV:ni-titanium = "82c52e33a801e19af7187b1cf8da36673778f12f"

LIC_FILES_CHKSUM:ni-titanium = "file://LICENSE;md5=877fdcdaa5a0636e67b479c79335a6d1"
