MPM_DEVICE:ni-neon = "e320"

# RDEPENDS:${PN}:append:ni-neon = " \
#     linux-firmware-ni-neon-fpga \
# "
