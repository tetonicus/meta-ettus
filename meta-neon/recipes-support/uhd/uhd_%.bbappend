PACKAGECONFIG:ni-neon = "mpmd python"
