PACKAGECONFIG:append:ni-neon = " networkd resolved"
